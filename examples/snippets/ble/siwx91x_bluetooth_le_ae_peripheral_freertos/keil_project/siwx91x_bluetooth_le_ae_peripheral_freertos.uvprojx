# Keil uVision project siwx91x_bluetooth_le_ae_peripheral_freertos.uvprojx, settings and files
target siwx91x_bluetooth_le_ae_peripheral_freertos (6230000::V6.23::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: siwx91x_bluetooth_le_ae_peripheral_freertos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER, STM32F411xE, __Keil, SLI_SI917, SLI_SI917B0, SLI_SI91X_MCU_CONFIG_RADIO_BOARD_VER2, configUSE_POSIX_ERRNO, configNUM_SDK_THREAD_LOCAL_STORAGE_POINTERS=2, SL_CATALOG_FREERTOS_KERNEL_PRESENT, SL_CATALOG_KERNEL_PRESENT, SL_SI91X_SPI_HIGH_SPEED_ENABLE, SL_NET_COMPONENT_INCLUDED, SL_WIFI_COMPONENT_INCLUDED, SLI_SI91X_ENABLE_BLE, SL_SI91X_PRINT_DBG_LOG, SL_SI91X_ENABLE_LITTLE_ENDIAN, __ICCARM__
  c include: ../../../../../examples/snippets/ble/siwx91x_bluetooth_le_ae_peripheral_freertos;../../../../../components/device/silabs/si91x/wireless/sli_si91x_wifi_command_engine/inc;../../../../../components/device/silabs/si91x/wireless/firmware_upgrade;../../../../../components/service/network_manager/inc;../../../../../../../network_stack/network_stack_sdk/components/service/network_stack_common/inc;../../../../../resources/defaults/;../../../../../components/device/silabs/si91x/wireless/errno/inc;../../../../../components/common/inc;../../../../../components/device/silabs/si91x/wireless/spi_interface/inc;../../../../../components/device/silabs/si91x/wireless/sl_net/inc;../../../../../components/device/stm32/silabs_utility/common/inc;../../../../../components/device/silabs/si91x/wireless/ble/inc;../../../../../components/device/silabs/si91x/wireless/inc;../../../../../components/device/silabs/si91x/host_interface/inc;../../../../../components/protocol/wifi/inc;../../../../../components/device/stm32/board;../../../../../components/device/stm32/Core/Inc;../../../../../components/device/stm32/Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../components/device/stm32/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../components/device/stm32/Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../components/device/stm32/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../components/device/stm32/Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../../../../../components/device/stm32/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../components/device/stm32/Drivers/CMSIS/Include;../../../../../../../network_stack/network_stack_sdk/components/service/bsd_socket/inc;../../../../../components/sli_wifi/inc;../../../../../components/sli_buffer_manager/inc;../../../../../components/sli_buffer_manager/inc/si91x;../../../../../components/device/silabs/si91x/mcu/drivers/service/sl_log/inc;..\..\..\..\..\components\protocol\wifi\inc\sli_wifi_callback_framework.h;..\..\..\..\..\components\sli_queue_manager\inc;..\..\..\..\..\components\sli_command_engine\inc;..\..\..\..\..\components\sli_routing_utility\inc;..\..\..\..\..\components\sli_event_engine\inc;..\..\..\..\..\components\device\silabs\si91x\mcu\hal\sli_hal_si91x\inc;..\..\..\..\..\components\device\silabs\si91x\wireless\sli_si91x_wifi_event_handler\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ../../../../../components/device/stm32/: startup_stm32f411xe.s
    ../../../../../components/protocol/wifi/src/: sli_wifi_callback_framework.c
  group Application/User/Core
    ../../../../../components/device/stm32/Core/Src/: main.c
    ../../../../../examples/snippets/ble/siwx91x_bluetooth_le_ae_peripheral_freertos/: app.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../components/device/stm32/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
    ../../../../../components/device/stm32/Core/Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../../../../../components/device/stm32/Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../../../../../components/device/stm32/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../components/device/stm32/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../components/device/stm32/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../components/device/stm32/Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    ../../../../../components/device/stm32/Core/Src/: freertos.c
  group components/service
    ../../../../../components/service/network_manager/src/: sl_net_basic_profiles.c sli_net_common_utility.c sl_net.c sli_net_credentials.c
    ../../../../../components/service/network_manager/src/si91x/: sl_net_credentials.c
    ../../../../../../../network_stack/network_stack_sdk/components/service/network_stack_common/src/: sli_net_ip_config.c sl_net_dns_utility.c
    ../../../../../components/device/silabs/si91x/wireless/sl_net/src/: sli_net_si91x_utility.c
  group components/ble
    ../../../../../components/device/silabs/si91x/wireless/ble/src/: rsi_ble_gap_apis.c rsi_ble_gatt_apis.c rsi_bt_ble.c rsi_bt_common_apis.c rsi_common_apis.c rsi_utils.c sl_si91x_ble.c
  group components/device
    ../../../../../components/device/silabs/si91x/wireless/sl_net/src/: sl_net_si91x.c sl_si91x_net_internal_stack.c sl_net_si91x_callback_framework.c sl_net_rsi_utility.c sl_net_si91x_integration_handler.c
    ../../../../../components/protocol/wifi/src/: sl_wifi_callback_framework.c sl_wifi_basic_credentials.c
    ../../../../../components/protocol/wifi/src/si91x/: sl_wifi.c
    ../../../../../components/device/silabs/si91x/wireless/host_mcu/stm32/: stm32_ncp_host.c
    ../../../../../components/device/silabs/si91x/host_interface/src/: sl_si91x_host_control.c
    ../../../../../components/device/silabs/si91x/wireless/memory/: malloc_buffers.c
    ../../../../../components/device/silabs/si91x/wireless/ncp_interface/: sl_si91x_ncp_driver.c
    ../../../../../components/device/silabs/si91x/host_interface/ncp_bus/spi/: sl_si91x_spi.c
    ../../../../../components/device/silabs/si91x/wireless/src/: sl_si91x_driver.c sli_si91x_driver.c sl_rsi_utility.c
  group components/common
    ../../../../../components/common/src/: sl_utility.c sli_utility.c sli_power_profile.c
  group common/silabs_utility
    ../../../../../components/device/stm32/silabs_utility/common/src/: sl_string.c sli_cmsis_os2_ext_task_register.c sl_host_core.c sl_mem_pool.c
  group components/errno
    ../../../../../components/device/silabs/si91x/wireless/errno/src/: sl_si91x_errno.c
    ../../../../../components/device/silabs/si91x/wireless/errno/inc/: errno.h
  group components/device/silabs/si91x/wireless/sli_si91x_wifi_command_engine
    ../../../../../components/device/silabs/si91x/wireless/inc/: sli_si91x_driver.h
    ../../../../../components/device/silabs/si91x/wireless/sli_si91x_wifi_command_engine/inc/: sli_si91x_wifi_command_engine.h sli_wifi_command_engine_config.h
    ../../../../../components/device/silabs/si91x/wireless/sli_si91x_wifi_command_engine/src/: sli_si91x_wifi_command_engine.c sli_si91x_wifi_command_engine_config.c
  group components/sli_wifi/src
    ../../../../../components/sli_wifi/src/: sli_wifi.c sli_wifi_utility.c
  group components/device/silabs/si91x/wireless/src/
    ../../../../../components/sli_wifi/src/: sli_wifi_power_profile.c
  group components/sli_buffer_manager/src
    ../../../../../components/sli_buffer_manager/src/: sli_buffer_manager.c
  group components/sli_routing_utility/src
    ../../../../../components/sli_routing_utility/src/: sli_routing_utility.c
  group components/sli_queue_manager/src
    ../../../../../components/sli_queue_manager/src/: sli_queue_manager.c
  group components/sli_command_engine/src
    ../../../../../components/sli_command_engine/src/: sli_command_engine.c
  group components/sli_event_engine/src
    ../../../../../components/sli_event_engine/src/: sli_event_engine.c
  group components/device/silabs/si91x/mcu/hal/sli_hal_si91x/src
    ../../../../../components/device/silabs/si91x/mcu/hal/sli_hal_si91x/src/: sli_hal_si91x.c
  group components/device/silabs/si91x/wireless/sli_si91x_wifi_event_handler/src
    ../../../../../components/device/silabs/si91x/wireless/sli_si91x_wifi_event_handler/src/: sli_si91x_wifi_event_handler.c
